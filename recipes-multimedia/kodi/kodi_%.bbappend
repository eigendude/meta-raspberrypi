PACKAGECONFIG += "raspberrypi"
