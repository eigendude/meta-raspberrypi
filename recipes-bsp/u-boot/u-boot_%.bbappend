DEPENDS_append_rpi = " rpi-u-boot-scr"

UBOOT_SUFFIX_raspberrypi3 = "bin"
SPL_BINARY_raspberrypi3 = "SPL"
